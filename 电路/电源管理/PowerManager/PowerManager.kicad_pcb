# Repository ZeshuLiu/PolaMiyaHardware

File ReadMe.md:

# PolaMiyaHardware - 宝丽来相机改装项目

宝丽来相机自动化改装项目的机械与电路设计部分。

2026-10-19 工作快照：保存主控与电源管理 PCB、PowerManager 工程设置及 STEP、两块板的交互 BOM；同步 Rev3 总装、片仓、底壳、显示屏按钮/支架/盖板、测距组件与镜头总成，收录电池及相关电子零件模型、STL 和 3MF 文件。本次为当前设计文件归档，未执行 ERC/DRC、SolidWorks 重建或装配干涉检查。

吐片电机实机结论：用户确认启动冲转及随后约半速的问题来自驱动芯片限流，解除电流限制后运行正常。具体解除方式与当前阈值未提供，本次不据此改写生产 BOM、网表或加工包。

> 完整项目：https://github.com/ZeshuLiu/PolaMiya
> 软件固件仓库：https://github.com/ZeshuLiu/PolaMiyaSoftware

## 仓库结构

| 子目录 | 说明 |
|--------|------|
| [电路/](电路/) | KiCad 电路设计 |
| [结构Rev2N/](结构Rev2N/) | Rev2N 机械结构 3D 模型 (STL/STP) |
| [结构Rev3/](结构Rev3/) | Rev3 机械结构与对焦机构 |
| [结构与PCB兼容性表](结构与PCB兼容性表.md) | 各结构对应的 PCB 及版本 |

### 电路设计

| 模块 | 说明 |
|------|------|
| [主控器：当前工程](电路/主控器/PM_Controller/) | Rev 2.0，ESP32-S3-WROOM-1，机械装配已确认，已投产，等待首件验证 |
| [主控器：Rev 1.3 历史归档](电路/主控器/主要历史版本/PM_Controller_Rev1.3/) | Rev2N 对应的冻结版本，与 DispKey Rev 1.0 绑定，见[版本说明](电路/主控器/主要历史版本/PM_Controller_Rev1.3/版本说明.md) |
| [DispKey：Rev 1.0 历史归档](电路/主控器/主要历史版本/PM_Controller_Rev1.3/DispKey/) | 与 PM_Controller Rev 1.3 绑定的屏幕与按键模块 |
| [电机驱动](电路/电机驱动/MotroDrive/) | 吐片电机驱动板 |
| [闪光灯转接](电路/闪光灯转接/FlashAdapter/) | 闪光灯转接板 |
| [对焦组件](电路/对焦组件/) | Rev3 对焦驱动板，PCB Rev 1.0 |
| [电源管理](电路/电源管理/PowerManager/) | Power Manager Rev 1.0，保存原理图、PCB、项目规则、加工资料及历史审查记录 |

> 当前主控器 Rev 2.0、对焦组件及电源管理板由 **KiCad 10** 保存，历史主控器、显示按键、电机驱动和闪光灯转接工程由 **KiCad 9** 保存。加工包和 BOM 位于相应模块的 `production/` 子目录中；使用前请核对兼容性表和输出快照。主控器 Rev 2.0 的投产验证资料为 `电路/主控器/PM_Controller/production/Rev_2_0/PM_Controller_2.0.zip` 及同目录 BOM、坐标、位号和网络表。电源管理板 Rev 1.0 的资料位于 `电路/电源管理/PowerManager/production/Rev_1_0/`。

### 当前硬件快照整理

- 主控器 Rev 2.0 的五份投产资料移入 `production/Rev_2_0/`。加工 ZIP 与原快照字节一致，BOM、位号、网络表和坐标内容未变，仅存在文本行尾差异。
- 新增 Power Manager Rev 1.0 工程和加工资料。当前原理图、PCB 与 BOM 的 C7/C8/C9/C10 均带 25 V 标注，C11 均为 100 nF。历史审查对应的工程哈希已不同，见[快照说明](电路/电源管理/PowerManager/原理图审查.md)。本次未重新执行 ERC/DRC 或通电验证。
- 主控 SolidWorks 装配移至 [结构Rev3/电子部分/PM_Controller R2_0.SLDASM](<结构Rev3/电子部分/PM_Controller R2_0.SLDASM>) 并保存内容更新；Rev3 总装、主片仓零件和片仓组合体同时更新。本次仅核对文件变化，未在 SolidWorks 中验证装配引用、重建或干涉。

主控器后续更新在 `电路/主控器/PM_Controller/` 中进行，该工程已开始独立的 Rev 2.0 设计；`主要历史版本/PM_Controller_Rev1.3/` 保存冻结的旧版，并在其 `DispKey/` 子目录保存绑定的 Display Key Rev 1.0。历史 Display Key 不自动视为兼容新版主控器。每次重大版本归档应保存完整工程、绑定的配套 PCB、依赖库、加工资料和版本说明。

### PM_Controller Rev 2.0 状态与 Features

2026-10-06：PM_Controller Rev 2.0 已投产，机械装配已确认无问题，等待首件验证。当前全部待验证和待完善事项统一纳入 F01–F11，作为本轮投产验证的非阻断 feature 随首件验证、参数定型和固件适配推进；实测完成后更新对应 feature 状态。已投产不等同于量产验证已通过。

| Feature | 内容与验证目标 |
| --- | --- |
| F01 电机电流采样与限流调优 | 定型 C8/R12；IPROPI 就地小电容滤波与 ADC 大电容滤波分开配置，核对堵转峰值及限流响应。暂定 1 µF 与 R2=1 kΩ 对应约 1 ms 时间常数。 |
| F02 电池采样与关机低功耗 | 核对 U17 在 3.3 V 供电、满电电池约 4.2 V 输入及掉电过程中的允许范围；定型 C32，验证 GPIO3 储能泄放、隔离和关机电流。 |
| F03 吐片事件保持与冷启动 | 明确 U3 冷上电预置或软件初始化；主电源重启时保留真实事件，首次接入电池时完成初态处理。 |
| F04 电源动态调优 | 按实料的 DC 偏压降容、ESR 和分布位置核对输出电容；验证启动、轻载、无线发射叠加电机启停、制动回灌和电压恢复。 |
| F05 物料定型与生产版本管理 | 定型 C8/C32、L1 的 Isat/Irms/DCR、C7 耐压/浪涌/ESR、MLCC 有效容量、ESP32 存储容量后缀及 EEPROM 精确型号/脚序/容量；明确 FPC 二选一装配及 DNP，保持加工包、BOM 和坐标同一快照。 |
| F06 PowerPAD 装配工艺 | U5 EP 内 6 个 0.30 mm 散热孔与整块 2.41×3.10 mm 锡膏开窗配合，确认钢网锡量及封孔工艺，检查首件焊接和空洞。 |
| F07 电机与充电工作裕量 | 核对名义约 2.10 A 电机限流、最重吐片负载、堵转停机及 U5/U14/L2 温升；按最终充电芯片规格确认 RPROG=2.1 kΩ 的充电电流，验证 U2 实际电流与热降额。 |
| F08 USB 接口验证 | 验证正反插、枚举、传输与最终叠层阻抗；适配 U18 CT 浮空时 12–28 ms 插入延迟，验证满电轻载拔线后 GPIO21 在 3 ms 内变低。 |
| F09 ESP32 配套固件适配 | 核对 GPIO39=/PL、GPIO40=CLK、GPIO41=Q7，74HC165 D0–D7 为 KEY1–KEY6、CHG、STB，SPI 模式 2；实现锁存恢复、ADC 与电机保护，并明确 GPIO3/eFuse/JTAG 策略。现有 STM32 工程保留为历史固件。 |
| F10 闪光同步兼容范围 | 明确 H3.1 正极/H3.2 负极、目标闪光灯触发电流及工作限额；TLP291 的 VCEO=80 V、VECO=7 V、IC=50 mA 为绝对最大值，工作规格保留裕量；按需求扩展高压或无极性兼容。 |
| F11 工程表达与维护 | 完善导入符号电气类型、NC/PWR_FLAG、库型号及人工豁免说明，保持文档、物料和当前设计一致。 |

### 结构设计

| 组件 | 说明 |
|------|------|
| 镜头总成 | Mamiya Press 127mm 镜头安装座 |
| 片仓总成 | 宝丽来相纸仓 |
| 吐片机构 | 电动吐片下巴与齿轮组 |
| 外壳 | 相机主体外壳 |
| 全息取景器 | 计划中的升级部件 |

> 所有 STL 文件位于各组件的 `STL/` 子目录中，可用 A1 mini 或 Voron0 等小型 3D 打印机打印。

## 技术栈

| 类别 | 工具/平台 |
|------|----------|
| **PCB 设计** | 当前主控器及对焦组件 KiCad 10；历史工程 KiCad 9 |
| **结构设计** | SolidWorks / 兼容 CAD 软件 |
| **固件** | 当前主控器 ESP32-S3；历史及配套 STM32 工程使用 STM32CubeMX + HAL 库、Keil MDK-ARM |
| **3D 打印** | PLA/PETG，A1 mini / Voron0 |

## 采购清单

主要采购件：
- Mamiya Press 127mm 镜头（不需要调焦桶）
- 宝丽来 AF5000（用于拆解吐片下巴、吐片电机和齿轮组）

## 使用方法

### 相机操作
- **开机/关机**：长按机身左下角按钮 2 秒
- **吐片**：三向按钮长按中键 2 秒启动吐片电机，短按中键停止，随后推动侧面推杆吐出相纸
- **测距**：开机即运行

### 功能
- ✅ 电动吐片
- ✅ 电子测距
- 🔄 自动对焦（计划中）
- 🔄 测光（计划中）
- 🔄 全息取景器（计划中）

## Rev2N 使用注意

| 事项 | 说明 |
|------|------|
| 吐片口密封性能不好，严禁在有相纸的情况下打开片仓 | 使用中注意 |

## 已修复问题

| 问题 | 修复版本 |
|------|----------|
| 吐片电机运行导致测距停止（硬件干扰） | Rev1.2 |
| 温度传感器位置不合理，受芯片发热影响大 | Rev1.2 |

## 相关资源

- [样片与演示]() - 待更新
- [装配指南](结构Rev2N/) - 参考总装配 STEP 文件

## KiCad design 电路/电源管理/PowerManager/PowerManager.kicad_pcb

Parts:
C1: 2.2uf; C_0603_1608Metric
C2: 10uf; C_0805_2012Metric
C3, C4: 100nf; C_0603_1608Metric
C5: 39nf; C_0603_1608Metric
C6: 100pf; C_0603_1608Metric
C7: 100nf 25V; C_0603_1608Metric
C8, C9, C10: 47uf 25V; C_1210_3225Metric
C11: 100nf; C_0805_2012Metric
H3, H4: MountingHole; MountingHole_2.7mm_M2.5
L1: 1.8uH; L_Coilcraft_XAL7070-XXX; LCSC Part C19630747
M1, M2, M3, M4: MARKER
Q1: IRF7324TRPBF; SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL; MPN IRF7324TRPBF; LCSC Part C169765
R1: 40.2k; R_0603_1608Metric
R2: 681k; R_0603_1608Metric
R3: 48.7k; R_0603_1608Metric
R4: 100k; R_0603_1608Metric
R5, R6: 100; R_0603_1608Metric
R7: 0; R_0603_1608Metric
U1: TPS61288LRQQR; VQFN-HR-11_L3.0-W2.5-P0.50-TL; MPN TPS61288LRQQR; LCSC Part C7498841
U2: ZX-ZH1.5-2PWT; CONN-SMD_2P-P1.50_ZX-ZH1.5-2PWT; MPN ZX-ZH1.5-2PWT; LCSC Part C19272405
U3: ZX-PH2.0-WT4P; CONN-SMD_4P-P2.00_C2001RS10411M0101RC; MPN ZX-PH2.0-WT4P; LCSC Part C7429691
U8: ZX-XH2.54-5PWT; CONN-SMD_5P-P2.54_MEGASTAR_ZX-XH2.54-5PWT; MPN ZX-XH2.54-5PWT; LCSC Part C7429674

Connections:
+BATT: Q1.1 (S1), Q1.3 (S2), R4.1, R7.1, U3.3, U3.4
/SW: C4.2, L1.2, U1.4 (SW), U1.9 (SW)
/SWITCH: C11.1, R4.2, R5.1, R6.1, U2.1
/VIN_ON: C2.1, C3.1, L1.1, Q1.5 (D2), Q1.6 (D2), Q1.7 (D1), Q1.8 (D1), U1.6 (EN), U1.7 (VIN)
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, R3.2, U1.3 (PGND), U1.10 (AGND), U2.2, U3.1, U3.2, U8.4, U8.5
unnamed: C5.1, R1.2
unnamed: Q1.2 (G1), R5.2
unnamed: Q1.4 (G2), R6.2
unnamed: R7.2, U8.3
unnamed: C4.1, U1.8 (BST)
unnamed: C6.1, R1.1, U1.2 (COMP)
unnamed: R2.2, R3.1, U1.1 (FB)
unnamed: C1.1, U1.11 (VCC)
VCC: C7.1, C8.1, C9.1, C10.1, R2.1, U1.5 (VOUT), U8.1, U8.2

Notes on the sheet:
电池应加保护板
BAT只用来测量电压

Board: 2 copper layers, 41.5 x 25.0 mm, 30 parts (0 on the bottom side), 14 nets.

File 电路/电源管理/PowerManager/production/Rev_1_0/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,2.2uf,
"C10, C8, C9",1210,3,47uf 25V,
C11,0805,1,100nf,
C2,0805,1,10uf,
"C3, C4",0603,2,100nf,
C5,0603,1,39nf,
C6,0603,1,100pf,
C7,0603,1,100nf 25V,
L1,L_Coilcraft_XAL7070-XXX,1,1.8uH,C19630747
"M1, M2, M3, M4",MARKER,4,~,
Q1,SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL,1,IRF7324TRPBF,C169765
R1,0603,1,40.2k,
R2,0603,1,681k,
R3,0603,1,48.7k,
R4,0603,1,100k,
"R5, R6",0603,2,100,
R7,0603,1,0,
U1,VQFN-HR-11_L3.0-W2.5-P0.50-TL,1,TPS61288LRQQR,C7498841
U2,CONN-SMD_2P-P1.50_ZX-ZH1.5-2PWT,1,ZX-ZH1.5-2PWT,C19272405
U3,CONN-SMD_4P-P2.00_C2001RS10411M0101RC,1,ZX-PH2.0-WT4P,C7429691
U8,CONN-SMD_5P-P2.54_MEGASTAR_ZX-XH2.54-5PWT,1,ZX-XH2.54-5PWT,C7429674

## KiCad design 电路/主控器/PM_Controller/PM_Controller.kicad_pcb

Parts:
C1, C2, C4, C17, C18, C21: 1uf; C_0603_1608Metric
C3: 22uf; C_0805_2012Metric
C5, C6: DNP; C_0603_1608Metric; not fitted
C7: 220uf; CP_EIA-7343-31_Kemet-D
C8: TBD(10nf); C_0603_1608Metric
C9, C10, C22, C23, C29, C30: 10uf; C_0805_2012Metric
C11, C19, C20, C24, C28: 100nf; C_0603_1608Metric
C12, C13, C14, C25, C26: 22uf; C_0603_1608Metric
C15, C27, C31, C33: 100nF; C_0603_1608Metric
C16: 1nf; C_0603_1608Metric
C32: TBD(1uf); C_0603_1608Metric
FPC1: AFC01-S08FCA-00; FPC-SMD_P0.50-8P_FGS-XJ-H2.0; MPN AFC01-S08FCA-00; LCSC Part C262657
FPC2: AFC11-S08ICA-00; CONN-TH-8P_AFC11-S08ICA-00; MPN AFC11-S08ICA-00; LCSC Part C262497
H1, H2, H3: WAFER-PH2.0-2PWB; CONN-SMD_2P-P2.00_XUNPU_WAFER-PH2.0-2PWB; MPN WAFER-PH2.0-2PWB; LCSC Part C3029440
H4, H5, H6, H7: MountingHole; MountingHole_3.2mm_M3
H8, H9: MountingHole; MountingHole_2.2mm_M2
J1: Conn_01x04_Pin; PinHeader_1x04_P1.27mm_Vertical
JP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm
L1: 2.2uH; L_Coilcraft_1008HQ_2520Metric
L2: 3.3uH; L_Changjiang_FXL0530
Q1, Q2: FDV301N; SOT-23
Q3: SS8550; SOT-23
R1, R3, R4, R6, R9, R10, R14, R19, R20, R21, R23, R24, R31, R32, R33, R34, R35, R36, R37, R38, R56: 10k; R_0603_1608Metric
R2, R18, R57: 1k; R_0603_1608Metric
R5: 33.2k; R_0603_1608Metric
R7, R8, R39, R40: 100k; R_0603_1608Metric
R11, R13: 100; R_0603_1608Metric
R12, R28, R29: 0; R_0603_1608Metric
R15, R16: 4.7k; R_0603_1608Metric
R17: 10; R_0603_1608Metric
R22: 68.1k; R_0603_1608Metric
R25: 390; R_0603_1608Metric
R26, R27: 5.1k; R_0603_1608Metric
R30: 2.1k (RPROG); R_0603_1608Metric
R47, R48, R49: 499; R_0603_1608Metric
R50: 10k; R_0603_1608Metric; not fitted
R58: 10.1k; R_0603_1608Metric
R59: 680; R_0603_1608Metric
SW1, SW2, SW3, SW4, SW5: TS-1088R-02026; SW-SMD_L3.9-W3.0-P4.45; MPN TS-1088R-02026; LCSC Part C455280
U1: ESP32-S3-WROOM-1
U2: TP4057; TSOT-23-6
U3: SN74AUP1G74DCUR; VSSOP-8_L2.1-W2.4-P0.50-LS3.2-BR; MPN SN74AUP1G74DCUR; LCSC Part C140267
U4, U14: TPS563201; SOT-23-6
U5: DRV8251ADDAR; SOPOWERPAD-8_L4.9-W3.9-P1.27-LS6.0-TL-EP; MPN DRV8251ADDAR; LCSC Part C5218844
U6: 74HC165; SOIC-16_3.9x9.9mm_P1.27mm
U7: USBLC6-2SC6; SOT-23-6
U8: ZX-XH2.54-5PWT; CONN-SMD_5P-P2.54_MEGASTAR_ZX-XH2.54-5PWT; MPN ZX-XH2.54-5PWT; LCSC Part C7429674
U9, U15: ZX-ZH1.5-4PWT; CONN-SMD_4P-P1.50_ZX-ZH1.5-4PWT; MPN ZX-ZH1.5-4PWT; LCSC Part C19272407
U10: TPS7A0233PDBVR; SOT-23-5_L2.9-W1.6-P0.95-LS2.8-BR; MPN TPS7A0233PDBVR; LCSC Part C2887324
U11: SN74AUP1G17DBVR; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; MPN SN74AUP1G17DBVR; LCSC Part C183012
U12: 24C64; SOT-23-5
U13: ZX-ZH1.5-3PWT; CONN-SMD_3P-P1.50_ZX-ZH1.5-3PWT; MPN ZX-ZH1.5-3PWT; LCSC Part C19272406
U16: TLP291; SOIC-4_4.55x2.6mm_P1.27mm
U17: TPG4599S6; TSOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; MPN TPG4599S6; LCSC Part C42449027
U18: TPS3808G01DBVR; SOT-23-6
U19: ZX-ZH1.5-5PWT; CONN-SMD_5P-P1.50_ZX-ZH1.5-5PWT; MPN ZX-ZH1.5-5PWT; LCSC Part C19272408
USB1: MC-402L68; USB-C-SMD_MC-402L68; MPN MC-402L68; LCSC Part C47326494

Connections:
+3.3V: C2.2, C3.2, C4.2, C12.1, C13.1, C14.1, C15.1, C27.1, C31.1, C33.1, FPC1.2, FPC2.7, J1.1, L1.2, Q3.2 (E), R1.2, R5.1, R6.1, R9.2, R15.2, R16.2, R19.1, R23.2, R31.1, R32.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, R50.2, R56.2, U1.2 (3V3), U5.4 (VREF), U6.16 (VCC), U9.1, U12.4 (VCC), U17.1 (SELECT1), U17.2 (V+), U18.6 (VDD), U19.1
+6V: C7.1, C25.1, C26.1, C28.1, L2.2, R22.1, U5.5 (VM)
+BATT: C17.1, C30.1, U2.3 (BAT), U8.3, U10.1 (IN), U10.3 (EN), U17.6 (NO)
/#FILM_KEY_CLR: Q2.3 (D), R10.1, U3.7 (#PRE)
/#FILM_TRG: R13.1, U3.5 (Q)
/ADC_BAT: C32.2, R39.2, R40.1, U1.15 (IO3)
/ADC_BAT_BAT: R39.1, U17.5 (CO)
/ADC_MT: C8.2, R12.1, U1.12 (IO8)
/BAT_CHG_OD: R38.2, U2.1 (~CHRG), U6.5 (D6)
/BAT_STB_OD: R37.2, U2.5 (STDBY), U6.6 (D7)
/ESP_BOOT: R50.1, SW4.1, U1.27 (IO0)
/ESP_EN: C1.2, R1.1, SW5.1, U1.3 (EN)
/ESP_FILM_CLR: R11.2, R14.2, U1.7 (IO7)
/ESP_FILM_TRG: Q1.3 (D), R9.1, U1.6 (IO6)
/ESP_KEY1: R31.2, SW3.1, U6.11 (D0)
/ESP_KEY2: R32.2, SW2.1, U6.12 (D1)
/ESP_KEY3: R33.2, SW1.1, U6.13 (D2)
/ESP_KEY4: R36.2, U6.14 (D3), U19.2
/ESP_KEY5: R35.2, U6.3 (D4), U19.4
/ESP_KEY6: R34.2, U6.4 (D5), U19.3
/ESP_RXD0: J1.3, U1.36 (RXD0)
/ESP_RXD1: U1.5 (IO5), U9.3
/ESP_RXD2: U1.10 (IO17), U15.3
/ESP_SCL: R16.1, U1.8 (IO15), U12.1 (SCL)
/ESP_SDA: R15.1, U1.9 (IO16), U12.3 (SDA)
/ESP_TXD0: J1.2, R47.1
/ESP_TXD1: R49.2, U9.2
/ESP_TXD2: R48.2, U15.2
/ESP_UD+: R29.1, U7.3 (I/O2)
/ESP_UD-: R28.1, U7.1 (I/O1)
/FILM_KEY: C21.1, U11.2 (A), U13.2
/FLASH_TRG: R24.2, R25.2, U1.31 (IO38)
/LCD_BLK: R18.1, U1.17 (IO9)
/LCD_CLK: FPC1.3, FPC2.6, U1.21 (IO13)
/LCD_CS: FPC1.1, FPC2.8, U1.22 (IO14)
/LCD_DC: FPC1.5, FPC2.4, U1.19 (IO11)
/LCD_MOSI: FPC1.4, FPC2.5, U1.20 (IO12)
/LCD_RES: FPC1.6, FPC2.3, U1.18 (IO10)
/LEDA: FPC1.8, FPC2.1, R17.2
/MASPI_CLK: U1.33 (IO40), U6.2 (CP)
/MASPI_CS: R6.2, U1.32 (IO39), U6.1 (~PL)
/MASPI_MISO: U1.34 (IO41), U6.9 (Q7)
/MOT_A: H1.1, U5.6 (OUT1)
/MOT_B: H1.2, U5.8 (OUT2)
/MotorIN2: U1.38 (IO2), U5.2 (IN2)
/MotorPWM_A: U1.39 (IO1), U5.3 (IN1)
/SHUT_TRG: H2.2, R23.1, U1.35 (IO42)
/USBPWR_DET: R56.1, U1.23 (IO21), U18.1 (~RESET)
/_1UD+: C6.2, R29.2, U1.14 (USB_D+)
/_1UD-: C5.2, R28.2, U1.13 (USB_D-)
/_UD+: U7.4 (I/O2), USB1.A6 (DP1)
/_UD-: U7.6 (I/O1), USB1.A7 (DN1)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, C33.2, FPC1.7, FPC2.2, H2.1, J1.4, Q1.2 (S), Q2.2 (S), R2.2, R4.2, R7.1, R14.1, R21.2, R24.1, R26.2, R27.2, R30.2, R40.2, R57.1, R59.1, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.2 (GND), U3.2 (D), U3.4 (GND), U4.1 (GND), U5.7 (GND), U5.9 (PAD), U6.8 (GND), U6.10 (DS), U6.15 (~CE), U7.2 (GND), U8.4, U8.5, U9.4, U10.2 (GND), U11.3 (GND), U12.2 (GND), U12.5 (WP), U14.1 (GND), U15.4, U16.2, U17.3 (GND), U17.4 (NC), U18.2 (GND), U19.5, USB1.1 (EH), USB1.2 (EH), USB1.3 (EH), USB1.4 (EH), USB1.B1 (GND), USB1.B12 (GND)
unnamed: H3.1, U16.4
unnamed: H3.2, U16.3
unnamed: JP1.2 (B), U15.1
unnamed: Q1.1 (G), R13.2
unnamed: Q2.1 (G), R11.1
unnamed: Q3.1 (B), R18.2, R19.2
unnamed: Q3.3 (C), R17.1
unnamed: R7.2, U13.3
unnamed: R8.1, U13.1
unnamed: R25.1, U16.1
unnamed: R49.1, U1.4 (IO4)
unnamed: R48.1, U1.11 (IO18)
unnamed: R47.2, U1.37 (TXD0)
unnamed: R30.1, U2.6 (PROG)
unnamed: R3.1, U4.5 (EN)
unnamed: C11.1, L1.1, U4.2 (SW)
unnamed: C11.2, U4.6 (VBST)
unnamed: R4.1, R5.2, U4.4 (VFB)
unnamed: R2.1, R12.2, U5.1 (IPROPI)
unnamed: U3.1 (CLK), U11.4 (Y)
unnamed: R20.1, U14.5 (EN)
unnamed: C24.1, L2.1, U14.2 (SW)
unnamed: C24.2, U14.6 (VBST)
unnamed: R21.1, R22.2, U14.4 (VFB)
unnamed: C16.2, R57.2, R58.1, U18.5 (SENSE)
unnamed: R26.1, USB1.A5 (CC1)
unnamed: R27.1, USB1.B5 (CC2)
VAA: C18.1, C19.1, C20.1, R8.2, R10.2, U3.6 (#CLR), U3.8 (VCC), U10.5 (OUT), U11.5 (VCC)
VBUS: C29.1, R58.2, R59.2, U2.4 (V_{CC}), U7.5 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)
VCC: C9.1, C10.1, C22.1, C23.1, JP1.1 (A), R3.2, R20.2, U4.3 (VIN), U8.1, U8.2, U14.3 (VIN)

Notes on the sheet:
(CPOL=1, CPHA=0), MSB first;

Board: 4 copper layers, 47.5 x 96.0 mm, 124 parts (0 on the bottom side), 83 nets.

File 电路/主控器/PM_Controller/production/Rev_2_0/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C17, C18, C2, C21, C4",0603,6,1uf,
"C10, C22, C23, C29, C30, C9",0805,6,10uf,
"C11, C15, C19, C20, C24, C27, C28, C31, C33",0603,9,100nf,
"C12, C13, C14, C25, C26",0603,5,22uf,
C16,0603,1,1nf,
C3,0805,1,22uf,
"C32, C8",0603,2,TBD(1uf),
"C5, C6",0603,2,DNP,
C7,CP_EIA-7343-31_Kemet-D,1,220uf,
FPC1,FPC-SMD_P0.50-8P_FGS-XJ-H2.0,1,AFC01-S08FCA-00,C262657
FPC2,CONN-TH-8P_AFC11-S08ICA-00,1,AFC11-S08ICA-00,C262497
"H1, H2, H3",CONN-SMD_2P-P2.00_XUNPU_WAFER-PH2.0-2PWB,3,WAFER-PH2.0-2PWB,C3029440
J1,PinHeader_1x04_P1.27mm_Vertical,1,Conn_01x04_Pin,
L1,L_Coilcraft_1008HQ_2520Metric,1,2.2uH,
L2,L_Changjiang_FXL0530,1,3.3uH,
"Q1, Q2",SOT-23,2,FDV301N,
Q3,SOT-23,1,SS8550,
"R1, R10, R14, R19, R20, R21, R23, R24, R3, R31, R32, R33, R34, R35, R36, R37, R38, R4, R50, R56, R6, R9",0603,22,10k,
"R11, R13",0603,2,100,
"R12, R28, R29",0603,3,0,
"R15, R16",0603,2,4.7k,
R17,0603,1,10,
"R18, R2, R57",0603,3,1k,
R22,0603,1,68.1k,
R25,0603,1,390,
"R26, R27",0603,2,5.1k,
R30,0603,1,2.1k (RPROG),
"R39, R40, R7, R8",0603,4,100k,
"R47, R48, R49",0603,3,499,
R5,0603,1,33.2k,
R58,0603,1,10.1k,
R59,0603,1,680,
"SW1, SW2, SW3, SW4, SW5",SW-SMD_L3.9-W3.0-P4.45,5,TS-1088R-02026,C455280
U1,ESP32-S3-WROOM-1,1,ESP32-S3-WROOM-1,
U10,SOT-23-5_L2.9-W1.6-P0.95-LS2.8-BR,1,TPS7A0233PDBVR,C2887324
U11,SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR,1,SN74AUP1G17DBVR,C183012
U12,SOT-23-5,1,24C64,
U13,CONN-SMD_3P-P1.50_ZX-ZH1.5-3PWT,1,ZX-ZH1.5-3PWT,C19272406
"U14, U4",SOT-23-6,2,TPS563201,
"U15, U9",CONN-SMD_4P-P1.50_ZX-ZH1.5-4PWT,2,ZX-ZH1.5-4PWT,C19272407
U16,SOIC-4_4.55x2.6mm_P1.27mm,1,TLP291,
U17,TSOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL,1,TPG4599S6,C42449027
U18,SOT-23-6,1,TPS3808G01DBVR,
U19,CONN-SMD_5P-P1.50_ZX-ZH1.5-5PWT,1,ZX-ZH1.5-5PWT,C19272408
U2,TSOT-23-6,1,TP4057,
U3,VSSOP-8_L2.1-W2.4-P0.50-LS3.2-BR,1,SN74AUP1G74DCUR,C140267
U5,SOPOWERPAD-8_L4.9-W3.9-P1.27-LS6.0-TL-EP,1,DRV8251ADDAR,C5218844
U6,SOIC-16_3.9x9.9mm_P1.27mm,1,74HC165,
U7,SOT-23-6,1,USBLC6-2SC6,
U8,CONN-SMD_5P-P2.54_MEGASTAR_ZX-XH2.54-5PWT,1,ZX-XH2.54-5PWT,C7429674
USB1,USB-C-SMD_MC-402L68,1,MC-402L68,C47326494

## KiCad design 电路/主控器/主要历史版本/PM_Controller_Rev1.3/DispKey/DispKey.kicad_pcb

Parts:
C1, C2: 10uf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C11, C12: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
H2, H3, H5, H6: MountingHole_Pad; MountingHole_2.7mm_M2.5_DIN965_Pad
J1: Conn_01x02_Pin; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm
J2: Conn_01x03_Pin; SolderWire-0.1sqmm_1x03_P3.6mm_D0.4mm_OD1mm
J7, J10: Conn_02x04_Odd_Even; PinHeader_2x04_P1.27mm_Vertical
JP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm
LCD1: LCD1.69_240_280
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R13: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: sw_push_5.8x5.8mm
SW3: Direction3 Pin5
TP1: KEY3; TestPoint_Pad_2.0x2.0mm

Connections:
+2V5: J2.3, JP1.1 (A), SW1.3 (SW2), SW1.6 (SW2)
+3.3V: C1.1, C2.1, J7.7, J10.7, JP1.2 (B), LCD1.2 (VCC), R1.1, R11.2, R12.2, R13.2
/BLK: J7.8, LCD1.8 (BLK)
/D_CS: J7.6, LCD1.7 (CS)
/D_DC: J7.4, LCD1.6 (DC)
/D_RES: J7.2, LCD1.5 (RES)
/D_SCL: J7.5, LCD1.3 (SCL)
/D_SDA: J7.3, LCD1.4 (SDA)
/I2C2_SCL: J10.2
/I2C2_SDA: J10.4
/KEY0: C11.1, J10.6, R12.1, SW3.C
/KEY1: C10.1, J10.8, R11.1, SW3.D
/KEY2: C12.1, J10.5, R13.1, SW3.B
/KEY3: D1.2 (A), J10.3, TP1.1
/WKUP: J2.2, SW1.2 (COM), SW1.5 (COM)
GND: C1.2, C2.2, C10.2, C11.2, C12.2, H1.1, H2.1, H3.1, H5.1, H6.1, J2.1, J7.1, J10.1, LCD1.1 (GND), LCD1.H (Mount), SW1.1 (SW1), SW1.4 (SW1), SW3.A
unnamed: D1.1 (K), R1.2
unnamed: D2.2 (A), J1.2
unnamed: D2.1 (K), J1.1

Notes on the sheet:
电源按键
显示&按键

Board: 2 copper layers, 77.0 x 61.5 mm, 25 parts (5 on the bottom side), 17 nets.

File 电路/主控器/主要历史版本/PM_Controller_Rev1.3/DispKey/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0805,2,10uf,
"C10, C11, C12",0603,3,1uF,
"D1, D2",0805,2,LED,
J1,SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm,1,Conn_01x02_Pin,
"J10, J7",PinHeader_2x04_P1.27mm_Vertical,2,Conn_02x04_Odd_Even,
J2,SolderWire-0.1sqmm_1x03_P3.6mm_D0.4mm_OD1mm,1,Conn_01x03_Pin,
LCD1,LCD1.69_240_280,1,~,
R1,0603,1,10k,
"R11, R12, R13",0603,3,100k,
SW1,sw_push_5.8x5.8mm,1,~,
SW3,Direction3 Pin5,1,~,
TP1,TestPoint_Pad_2.0x2.0mm,1,KEY3,
