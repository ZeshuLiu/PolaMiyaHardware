# Repository ZeshuLiu/PolaMiyaHardware (continued)

## KiCad design 电路/主控器/主要历史版本/PM_Controller_Rev1.3/DispKey/DispKey.kicad_pcb (continued)

Board: 2 copper layers, 77.0 x 61.5 mm, 25 parts (5 on the bottom side), 17 nets.

File 电路/主控器/主要历史版本/PM_Controller_Rev1.3/DispKey/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0805,2,10uf,
"C10, C11, C12",0603,3,1uF,
"D1, D2",0805,2,LED,
J1,SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm,1,Conn_01x02_Pin,
"J10, J7",PinHeader_2x04_P1.27mm_Vertical,2,Conn_02x04_Odd_Even,
J2,SolderWire-0.1sqmm_1x03_P3.6mm_D0.4mm_OD1mm,1,Conn_01x03_Pin,
LCD1,LCD1.69_240_280,1,~,
R1,0603,1,10k,
"R11, R12, R13",0603,3,100k,
SW1,sw_push_5.8x5.8mm,1,~,
SW3,Direction3 Pin5,1,~,
TP1,TestPoint_Pad_2.0x2.0mm,1,KEY3,

## KiCad design 电路/主控器/主要历史版本/PM_Controller_Rev1.3/PM_Controller.kicad_pcb

Parts:
BT1: Battery_Cell; cr1220
C1, C2, C3, C25: 5pf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 100nf; C_0603_1608Metric
C5, C6, C11, C38: 22uf; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
C7, C21, C23, C26, C28, C29, C30, C31, C33, C36, C37: 100nf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C22, C27: 10uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10, C32, C34, C35: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12: 22uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C14, C24: 47uf; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
C17, C18, C19, C20: 22uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C39: 22uf; CP_EIA-3528-21_Kemet-B_HandSolder
C40: 1uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C41: 10uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
CHG1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: SS34; D_SMA
D3: SS32; D_SMA_Handsoldering
D4: 1N5819WS; D_SOD-323_HandSoldering
FB1: FerriteBead; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
FLASH1: Conn_01x02_Pin; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm_Relief
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
H5, H6, H7, H8, H9: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad_TopBottom
J1, J4: Conn_01x04_Socket; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J2, J3, J9: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
J5: Conn_01x02_Pin; SolderWire-0.5sqmm_1x02_P4.8mm_D0.9mm_OD2.3mm
J6: Conn_01x02_Pin; PinSocket_1x02_P2.00mm_Vertical
J7, J10: Conn_02x04_Odd_Even; PinHeader_2x04_P1.27mm_Vertical
J8: Conn_01x04_Pin; PinHeader_1x04_P2.00mm_Vertical
J11: Conn_02x06_Odd_Even; PinHeader_2x06_P1.27mm_Vertical
JP1, JP2: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm
L1, L2, L3: 4.7uH; L_APV_APH0650
NRST1, NRST2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
P3V3: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
PW_LED1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Q2, Q3, Q5, Q6: AO3400A; SOT-23
R1, R2, R8, R12, R14, R15, R23, R24, R27, R28, R31, R39, R41, R42: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: RPORG(1k); R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R13: 1.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R37: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R25, R26, R32, R40: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R29, R33, R34, R35, R36, R45: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R17, R18, R20, R21, R22: 100k(NC); R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R30, R38, R43: 150k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R44: 33k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U9: AT24CS08-SSHM; SOIC-8_3.9x4.9mm_P1.27mm
U2: AMS1117-3.3; SOT-223-3_TabPin2
U3: STM32G431RBTx; LQFP-64_10x10mm_P0.5mm
U5: BQ21040DBV; SOT-23-6_Handsoldering
U6, U11: TPS2552DDBVR; DBV0006A_TEX
U7: STM32L011D4Px; TSSOP-14_4.4x5mm_P0.65mm
U8: ME6211C25M5; SOT-23-5_HandSoldering
U10: TMP102xxDRL; SOT-563
U12: TLP127; MFSOP6-4_4.4x3.6mm_P1.27mm
U13: TLV61048DBVR; SOT-23-6_DBV_TEX
Y1: 32.768kHz; Crystal_C26-LF_D2.1mm_L6.5mm_Horizontal
Y2: 24Mhz; Crystal_DS26_D2.0mm_L6.0mm_Horizontal

Connections:
+2V5: C20.1, C21.1, C22.1, J4.3, R13.2, R16.2, R17.2, U7.10 (VDD), U8.5 (V_{OUT})
+3.3V: C12.1, C18.1, C24.1, C27.1, C28.1, C29.1, C30.1, C31.1, C34.2, C35.2, C36.2, FB1.1, J7.7, J8.1, J10.7, J11.11, J11.12, JP2.3 (B), P3V3.2 (B), R20.2, R21.2, R22.1, R28.2, R33.1, R34.1, R35.1, R36.1, R42.1, U1.8 (VCC), U2.2 (VO), U3.16 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD), U9.8 (VCC), U10.5 (V+)
+5V: C14.1, C39.1, C41.1, D1.1 (K), D4.1 (K), L2.1, R43.1
+5VA: C5.1, C10.1, D1.2 (A), J1.1, R30.2, R38.2, U5.6 (VIN)
+BATT: C6.1, C7.1, C8.1, C19.1, C37.1, J4.1, R4.2, R8.1, R41.1, U5.2 (OUT), U6.1 (IN), U8.1 (V_{IN}), U8.3 (CE), U11.1 (IN)
/#CHRG: CHG1.1 (K), U5.3 (~CHG)
/ADC1_15: R25.1, U3.24 (PB0)
/BAT_OUT: C11.1, C40.1, L1.1, R23.2, R45.2, U6.6 (OUT), U13.5 (VIN)
/BAT_OUT2: C38.1, L3.2, U11.6 (OUT)
/BLK: J7.8, R22.2, U3.55 (PD2)
/BOOT0: JP2.2 (C), U3.61 (PB8)
/C2P0: Q6.3 (D), R17.1, U7.11 (PA9)
/C2P1: Q5.3 (D), R16.1, U7.12 (PA10)
/D_CS: J7.6, U3.62 (PB9)
/D_DC: J7.4, U3.60 (PB7)
/D_RES: J7.2, U3.59 (PB6)
/D_SCL: J7.5, U3.56 (PB3)
/D_SDA: J7.3, U3.58 (PB5)
/EJCMT_EN: R6.1, U3.20 (PA6)
/FLASH_Trig: FLASH1.1, U12.6
/HSE+: C3.1, U3.5 (PF0), Y2.1
/HSE-: C25.1, U3.6 (PF1), Y2.2
/I2C2_SCL: J10.2, R34.2, U1.6 (SCL), U3.43 (PA9), U9.6 (SCL), U10.1 (SCL)
/I2C2_SDA: J10.4, R33.2, U1.5 (SDA), U3.42 (PA8), U9.5 (SDA), U10.6 (SDA)
/I2C3_SCL: J11.3, R35.2, U3.40 (PC8)
/I2C3_SDA: J11.5, R36.2, U3.41 (PC9)
/KEY0: J10.6, U3.12 (PA0)
/KEY1: J10.8, U3.13 (PA1)
/KEY2: J10.5, U3.18 (PA4)
/KEY3: J10.3, U3.21 (PA7)
/LPRX1: J9.2, U3.8 (PC0)
/LPTX1: J9.3, U3.9 (PC1)
/LSE+: C1.1, U3.3 (PC14), Y1.1
/LSE-: C2.1, U3.4 (PC15), Y1.2
/NRST1: C26.2, NRST2.2 (B), U3.7 (PG10)
/P2C0: Q3.3 (D), R20.1, U3.34 (PB12)
/P2C1: Q2.3 (D), R21.1, U3.35 (PB13)
/PC5: J11.10, U3.23 (PC5)
/PWR_EN: R8.2, U6.3 (#EN), U7.3 (PC15)
/PWR_EN_2: R41.2, U3.22 (PC4), U11.3 (#EN)
/PWR_KEY: R32.1, U7.8 (PA7)
/PWR_LED: PW_LED1.1 (K), U7.2 (PC14)
/PWR_SENS: R40.1, U3.11 (PC3)
/RX2: J8.3, U3.17 (PA3)
/RX3: J11.7, U3.33 (PB11)
/SHUT_Trig+: J6.1, JP1.3 (B), U3.19 (PA5)
/SPI3_MISO: J11.6, U3.53 (PC11)
/SPI3_MOSI: J11.8, U3.54 (PC12)
/SPI3_SCK: J11.4, U3.52 (PC10)
/SWCLK0: J3.3, U7.14 (PA14)
/SWCLK1: J2.3, U3.50 (PA14)
/SWDIO0: J3.2, U7.13 (PA13)
/SWDIO1: J2.2, U3.49 (PA13)
/TX2: J8.2, U3.14 (PA2)
/TX3: J11.9, U3.30 (PB10)
/UD+: J1.3, U3.46 (PA12)
/UD-: J1.2, U3.45 (PA11)
/WKUP: J4.2, R18.1, U7.5 (PA0)
/_C2P0_: Q6.1 (G), R2.1, U3.36 (PB14)
/_C2P1_: Q5.1 (G), R1.1, U3.37 (PB15)
/_FLASH_Trig_: JP1.1 (A), R26.1
/_P2C0_: Q3.1 (G), R14.1, U7.6 (PA1)
/_P2C1_: Q2.1 (G), R15.1, U7.7 (PA4)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C14.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, C24.2, C25.2, C26.1, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, C33.1, C34.1, C35.1, C36.1, C37.2, C38.2, C39.2, C40.2, C41.2, FLASH1.2, H5.1, H6.1, H7.1, H8.1, H9.1, J1.4, J2.4, J3.4, J4.4, J5.2, J7.1, J8.4, J9.4, J10.1, J11.1, J11.2, NRST1.1 (A), NRST2.1 (A), Q2.2 (S), Q3.2 (S), Q5.2 (S), Q6.2 (S), R1.2, R2.2, R3.2, R5.2, R7.2, R12.2, R14.2, R15.2, R18.2, R24.1, R27.2, R29.2, R31.1, R37.2, R39.1, R44.2, U1.4 (GND), U1.7 (WP), U2.1 (GND), U3.15 (VSS), U3.27 (VSSA), U3.31 (VSS), U3.47 (VSS), U3.63 (VSS), U5.5 (GND), U6.2 (GND), U7.9 (VSS), U8.2 (V_{SS}), U9.4 (GND), U9.7 (WP), U10.2 (GND), U10.4 (ADD0), U11.2 (GND), U12.3, U12.4, U13.2 (GND)
unnamed: BT1.1 (+), D3.2 (A)
unnamed: CHG1.2 (A), R4.1
unnamed: D3.1 (K), U3.1 (VBAT)
unnamed: D4.2 (A), L1.2, U13.1 (SW)
unnamed: J2.1, P3V3.1 (A)
unnamed: J5.1, R6.2
unnamed: J6.2, R42.2
unnamed: J9.1, L3.1
unnamed: JP1.2 (C), U12.1
unnamed: JP2.1 (A), R29.1
unnamed: C23.2, NRST1.2 (B), U7.4 (NRST)
unnamed: PW_LED1.2 (A), R13.1
unnamed: R23.1, R24.2, R25.2
unnamed: R30.1, R31.2, R32.2
unnamed: R38.1, R39.2, R40.2
unnamed: R27.1, U1.3 (A2)
unnamed: C17.1, L2.2, U2.3 (VI)
unnamed: R26.2, U3.51 (PA15)
unnamed: C32.2, C33.2, FB1.2, U3.28 (VREF+), U3.29 (VDDA)
unnamed: R3.1, U5.4 (ISET)
unnamed: R7.1, U5.1 (TS)
unnamed: R5.1, U6.5 (ILIM)
unnamed: R12.1, U7.1 (PB9)
unnamed: R28.1, U9.3 (A2)
unnamed: R37.1, U11.5 (ILIM)
unnamed: R45.1, U13.4 (EN)
unnamed: C4.1, R43.2, R44.1, U13.3 (FB)

Notes on the sheet:
EEPROM
电源管理
接口电平
上下拉
G474RETx 应该可用
相机功能
LDO
电池充电、升压
预留电源输出

Board: 4 copper layers, 90.0 x 61.5 mm, 132 parts (59 on the bottom side), 91 nets.

File 电路/主控器/主要历史版本/PM_Controller_Rev1.3/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BT1,cr1220,1,Battery_Cell,
"C1, C2, C25, C3",0603,4,5pf,
"C10, C32, C34, C35",0603,4,1uf,
"C11, C38, C5, C6",CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder,4,22uf,
C12,1206,1,22uf,
"C14, C24",CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder,2,47uf,
"C17, C18, C19, C20",0603,4,22uf,
"C21, C23, C26, C28, C29, C30, C31, C33, C36, C37, C4, C7",0603,12,100nf,
"C22, C27, C8",0603,3,10uf,
C39,CP_EIA-3528-21_Kemet-B_HandSolder,1,22uf,
C40,1206,1,1uf,
C41,1206,1,10uf,
"CHG1, PW_LED1",0805,2,LED,
D1,D_SMA,1,SS34,
D3,D_SMA_Handsoldering,1,SS32,
D4,D_SOD-323_HandSoldering,1,1N5819WS,
FB1,0805,1,FerriteBead,
FLASH1,SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm_Relief,1,Conn_01x02_Pin,
"J1, J4",JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal,2,Conn_01x04_Socket,
"J10, J7",PinHeader_2x04_P1.27mm_Vertical,2,Conn_02x04_Odd_Even,
J11,PinHeader_2x06_P1.27mm_Vertical,1,Conn_02x06_Odd_Even,
"J2, J3, J9",PinHeader_1x04_P2.54mm_Vertical,3,Conn_01x04_Socket,
J5,SolderWire-0.5sqmm_1x02_P4.8mm_D0.9mm_OD2.3mm,1,Conn_01x02_Pin,
J6,PinSocket_1x02_P2.00mm_Vertical,1,Conn_01x02_Pin,
J8,PinHeader_1x04_P2.00mm_Vertical,1,Conn_01x04_Pin,
"L1, L2, L3",L_APV_APH0650,3,4.7uH,
"Q2, Q3, Q5, Q6",SOT-23,4,AO3400A,
"R1, R12, R14, R15, R2, R23, R24, R27, R28, R31, R39, R41, R42, R8",0603,14,100k,
"R13, R4",0603,2,1.5k,
"R16, R17, R18, R20, R21, R22",0603,6,100k(NC),
"R25, R26, R32, R40, R6",0603,5,1k,
"R29, R33, R34, R35, R36, R45, R7",0603,7,10k,
R3,0603,1,RPORG(1k),
"R30, R38, R43",0603,3,150k,
"R37, R5",0603,2,22k,
R44,0603,1,33k,
"U1, U9",SOIC-8_3.9x4.9mm_P1.27mm,2,AT24CS08-SSHM,
U10,SOT-563,1,TMP102xxDRL,
"U11, U6",DBV0006A_TEX,2,TPS2552DDBVR,
U12,MFSOP6-4_4.4x3.6mm_P1.27mm,1,TLP127,
U13,SOT-23-6_DBV_TEX,1,TLV61048DBVR,
U2,SOT-223-3_TabPin2,1,AMS1117-3.3,
U3,LQFP-64_10x10mm_P0.5mm,1,STM32G431RBTx,
U5,SOT-23-6_Handsoldering,1,BQ21040DBV,
U7,TSSOP-14_4.4x5mm_P0.65mm,1,STM32L011D4Px,
U8,SOT-23-5_HandSoldering,1,ME6211C25M5,
Y1,Crystal_C26-LF_D2.1mm_L6.5mm_Horizontal,1,32.768kHz,
Y2,Crystal_DS26_D2.0mm_L6.0mm_Horizontal,1,24Mhz,

## KiCad design 电路/硬件Rev3电路/对焦组件/对焦组件.kicad_pcb

Board: 2 copper layers, 40.1 x 22.4 mm, 49 parts (0 on the bottom side), 28 nets.

Parts:
C1, C6, C7, C11, C19: 100nf; C_0603_1608Metric
C2: 22uf; CP_EIA-3216-18_Kemet-A
C3: 1uf; C_0603_1608Metric
C4, C5: 20pf; C_0603_1608Metric
C8: 47uf; C_0805_2012Metric
C9, C10: 10uf; C_0805_2012Metric
C12, C13, C14, C15, C16, C17, C18: 22uf; C_0603_1608Metric
CN1, CN2: HX SH-1.0-8PWT; CONN-SMD_8P-P1.00_HX-SH1.0-8PWT
FB1: FerriteBead; L_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: Conn_01x04_Pin; PinHeader_1x04_P1.27mm_Vertical
L1: 2.2uH; L_Coilcraft_1008HQ_2520Metric
R1, R3, R4: 10k; R_0603_1608Metric
R2: 4.7k; R_0603_1608Metric
R5: 33.2k; R_0603_1608Metric
R6, R7, R9, R10, R11: 10k 1%; R_0603_1608Metric
R8: 2.2k 1%; R_0603_1608Metric
R12: 1k; R_0603_1608Metric
TP2: BOOT; TestPoint_Pad_D1.0mm
TP3: GND; TestPoint_Pad_D1.0mm
TP4: 3.3V; TestPoint_Pad_D1.0mm
TP5: NRST; TestPoint_Pad_D1.0mm
TP6: VREF; TestPoint_Pad_D1.0mm
U1: DRV8251ADDAR; SOPOWERPAD-8_L4.9-W3.9-P1.27-LS6.0-TL-EP
U2: STM32F030F4Px; TSSOP-20_4.4x6.5mm_P0.65mm
U3: TPS563201; SOT-23-6
Y1: 8Mhz; Crystal_SMD_5032-2Pin_5.0x3.2mm

Connections:
+3V3: C1.1, C2.1, C3.1, C12.1, C13.1, C14.1, CN2.5, FB1.1, J1.1, L1.2, R5.1, R8.2, R10.2, R11.2, TP4.1 (1_1), U1.4 (VREF), U2.16 (VDD)
+6V: C7.1, C8.1, C9.1, C10.1, CN1.6, CN1.7, CN1.8, R3.2, R6.2, U1.5 (VM), U3.3 (VIN)
/ADC_3V3: C16.1, R8.1, R9.2, U2.7 (PA1)
/ADC_6V: C15.1, R6.1, R7.2, U2.11 (PA5)
/ADC_MT: R12.1, U2.14 (PB1)
/ADC_NTC1: C18.1, CN2.3, R10.1, U2.6 (PA0)
/ADC_NTC2: C17.1, CN2.4, R11.1, U2.10 (PA4)
/MOT_A: CN2.1, U1.6 (OUT1)
/MOT_B: CN2.2, U1.8 (OUT2)
/MOT_ENC_A: CN2.7, U2.12 (PA6)
/MOT_ENC_B: CN2.6, U2.13 (PA7)
/MotorPWM_A: U1.3 (IN1), U2.18 (PA10)
/MotorPWM_B: U1.2 (IN2), U2.17 (PA9)
/SWCLK: J1.3, U2.20 (PA14)
/SWDIO: J1.2, U2.19 (PA13)
/USART1 _RX: CN1.4, U2.9 (PA3)
/USART1 _TX: CN1.5, U2.8 (PA2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, CN1.1, CN1.2, CN1.3, CN2.8, J1.4, R1.1, R2.2, R4.2, R7.1, R9.1, TP3.1 (1_1), U1.7 (GND), U1.9 (PAD), U2.15 (VSS), U3.1 (GND)
unnamed: R2.1, R12.2, U1.1 (IPROPI)
unnamed: R1.2, TP2.1 (1_1), U2.1 (BOOT0)
unnamed: C19.1, TP5.1 (1_1), U2.4 (NRST)
unnamed: C4.1, U2.2 (PF0), Y1.2
unnamed: C5.1, U2.3 (PF1), Y1.1
unnamed: C6.1, FB1.2, TP6.1 (1_1), U2.5 (VDDA)
unnamed: R3.1, U3.5 (EN)
unnamed: C11.1, L1.1, U3.2 (SW)
unnamed: C11.2, U3.6 (VBST)
unnamed: R4.1, R5.2, U3.4 (VFB)

File 电路/硬件Rev3电路/对焦组件/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C11, C19, C6, C7",0603,5,100nf,
"C10, C9",0805,2,10uf,
"C12, C13, C14, C15, C16, C17, C18",0603,7,22uf,
C2,CP_EIA-3216-18_Kemet-A,1,22uf,
C3,0603,1,1uf,
"C4, C5",0603,2,20pf,
C8,0805,1,47uf,
"CN1, CN2",CONN-SMD_8P-P1.00_HX-SH1.0-8PWT,2,HX SH-1.0-8PWT,C22461263
FB1,0603,1,FerriteBead,
J1,PinHeader_1x04_P1.27mm_Vertical,1,Conn_01x04_Pin,
L1,L_Coilcraft_1008HQ_2520Metric,1,2.2uH,
"R1, R3, R4",0603,3,10k,
"R10, R11, R6, R7, R9",0603,5,10k 1%,
R12,0603,1,1k,
R2,0603,1,4.7k,
R5,0603,1,33.2k,
R8,0603,1,2.2k 1%,
TP2,TestPoint_Pad_D1.0mm,1,BOOT,
TP3,TestPoint_Pad_D1.0mm,1,GND,
TP4,TestPoint_Pad_D1.0mm,1,3.3V,
TP5,TestPoint_Pad_D1.0mm,1,NRST,
TP6,TestPoint_Pad_D1.0mm,1,VREF,
U1,SOPOWERPAD-8_L4.9-W3.9-P1.27-LS6.0-TL-EP,1,DRV8251ADDAR,C5218844
U2,TSSOP-20_4.4x6.5mm_P0.65mm,1,STM32F030F4Px,
U3,SOT-23-6,1,TPS563201,
Y1,Crystal_SMD_5032-2Pin_5.0x3.2mm,1,8Mhz,

## Commit log (part)

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2025-06-23 ZUI init
2025-06-29 电源显示ok
2025-07-01 吐片正常（废片测试）
2025-07-01 测距正常，下一步尽量改成用接收到idle，来防止误码。
2025-07-02 显示中加入核心以及PCB温度；后续应考虑测距使用接收到空闲中断避免误码导致中断。
2025-07-16 测距改成300ms一次，解决了测距卡死的问题
2025-07-16 修复定时器逻辑问题
2025-07-18 吐片后必须要重启电源才能测距
2025-07-19 Rev1.0版本可正常工作
2025-09-27 第二代机械结构ok
2025-11-23 闪关灯功能OK 准备给电机加一个斜坡
2025-11-23 电机软起动加入，效果有限无法防止激光雷达下电
2025-12-25 闪光灯ok
2026-01-05 闪光已经就绪，至此基本功能全部OK
2026-01-05 清理仓库
2026-01-05 Add License
2026-01-21 优化外壳与5V外部供电电路选择逻辑
2026-01-21 主控升级至Rev1.2，电机驱动 Rev1.1
    电机驱动修改后采用Mosfet控制高侧电源通路。主控配套进行了更改。
2026-02-02 更新了电机驱动以及主控器PCB
2026-02-03 测试Rev1.2版本PCB，吐片导致测距停止问题已经修复
    测试Rev1.2版本PCB
    1. 原有引脚可以直接兼容G474芯片
    2. 吐片导致测距停止问题已经修复
    目前吐片的PWM加载方式可以进行调整
2026-02-03 硬件1.3版本，调整闪光灯为默认过MCU
2026-02-08 机械：优化吐片机械结构；代码：吐片电机及屏幕显示逻辑调整，ADC采样逻辑调整
    机械：
    1. 吐片下巴处增加导向齿轮
    代码：
    1. 电机启动斜坡加载速率调整
    2. 充电主控芯片采用外部供电时关闭屏幕及LED闪烁
    3. 电池ADC增加一阶低通滤波
2026-02-14 所有修改，两盒底片测试OK
2026-02-27 新版本主片仓以及镜头机构设计，待测试
    主片仓与吐片钣金连接位置内移1.25mm；
    镜头机构重新设计连接机构，期望消除黑底；
    删除了结构吐片机构文件夹（内容早已合并入片仓总成，应删除）
2026-02-27 修复对焦距离问题
2026-03-06 重新整理打印文件
2026-03-08 新版本PM，解决底部偏暗
2026-03-14 增加多种尺寸的齿轮定位
2026-03-14 原本齿轮定位尺寸ok不应再加高度；修改电机驱动电路，但是电机驱动电路未完全ok
2026-03-14 驱动电路升级至R1.2 未验证
    R1.2 升压二极管改为SS34；储能电容改为连接原始电源GND；电路板改为单面布局
2026-03-19 开始设计全息取景器
2026-03-19 结构CNC条件具备，尚未调整螺纹孔
2026-03-20 更新 README，添加代码仓库链接
2026-03-20 将代码仓库链接移到 README 顶部
2026-03-21 更新许可证和说明文档
    - LICENSE.md: 移除子目录 LICENSE，统一使用 CERN-OHL-P-2.0，添加「除非另有说明」条款
    - ReadMe.md: 更新为硬件仓库专用说明，参考软件仓库格式
    - 删除 电路/LICENSE.md 和 结构 Rev2N/LICENSE.md
